# Keil uVision project servo_v1.uvprojx, settings and files
target servo_v1 (6240000::V6.24::ARMCLANG)
  device: STM32G431VBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801EFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: servo_v1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32G431xx,ENCODER_FAULT_TRIGGER_DIAGNOSTIC=2
  c misc: -ffp-mode=std -fno-finite-math-only
  c include: ../Core/Inc;../FOC/Inc;../Servo/Inc;../Modules/Driver_Communication/Inc;../Modules/Three_Phase_Driver/Inc;../Modules/Current_Sampling/Inc;../Modules/Encoder/Inc;../Tests/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x1f000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: servo_v1_servo_v1.sct
  group Application/Startup
    ./: startup_stm32g431xx.s
  group Application/Core
    ../Core/Src/: main.c gpio.c stm32g4xx_it.c stm32g4xx_hal_msp.c
    ../Core/Inc/: main.h gpio.h stm32g4xx_it.h stm32g4xx_hal_conf.h
  group Modules/Driver Communication
    ../Modules/Driver_Communication/Src/: i2c3_bus.c tim6_heartbeat.c stspin32g4.c drv_monitor.c
    ../Modules/Driver_Communication/Inc/: i2c3_bus.h tim6_heartbeat.h stspin32g4.h drv_monitor.h
  group Modules/Three-Phase Driver
    ../Modules/Three_Phase_Driver/Src/: pwm_sampling.c tim1_pwm.c
    ../Modules/Three_Phase_Driver/Inc/: pwm_sampling.h tim1_pwm.h
  group Modules/Current Sampling
    ../Modules/Current_Sampling/Src/: adc1_current_sampling.c current_sampling.c
    ../Modules/Current_Sampling/Inc/: adc1_current_sampling.h current_sampling.h
  group Modules/Encoder
    ../Modules/Encoder/Src/: mpt_t485.c mpt_t485_protocol.c encoder_calibration_record.c encoder_calibration_store.c mt6701_ssi.c spi3_encoder.c spi1_encoder.c mt6835.c encoder.c
    ../Servo/Src/: output_position.c encoder_calibration.c user_control.c output_position_math.c
    ../Modules/Encoder/Inc/: mt6701_ssi.h spi3_encoder.h spi1_encoder.h mt6835.h encoder.h
  group Modules/FOC
    ../FOC/Src/: foc_pi.c foc_current_tuning.c foc_modulation.c foc_modulation_lut.h foc_algorithm.c foc_interface.c
    ../FOC/Inc/: foc_pi.h foc_current_tuning.h foc_modulation.h foc_algorithm.h foc_interface.h foc_control_manager.h
  group Application/Servo Manager
    ../Servo/Src/: servo_manager.c speed_commission.c
    ../Servo/Inc/: servo_manager.h
  group Tests
    ../Tests/Src/: mt6701_spi3_test.c current_loop_test.c tim1_pwm_verify.c waveform_generator.c waveform_uart1_port.c
    ../Tests/Inc/: mt6701_spi3_test.h current_loop_test.h tim1_pwm_verify.h measurement_manager.h waveform_generator.h waveform_uart1_port.h
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_pwr_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_cortex.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
software components: CMSIS:CORE 6.2.0
